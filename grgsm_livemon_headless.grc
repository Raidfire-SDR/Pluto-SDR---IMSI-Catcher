options:
  parameters:
    author: Piotr Krysik
    category: Custom
    description: 'Interactive monitor of a single C0 channel with analysis performed by Wireshark (command to run wireshark: sudo wireshark -k -f udp -Y gsmtap -i lo)'
    generate_options: no_gui
    id: grgsm_livemon_headless
    output_language: python
    run_options: run
    title: Gr-gsm Livemon
  states: {}

blocks:
- name: args
  id: parameter
  parameters:
    label: Device Arguments
    type: str
    value: '""'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(rec_len*samp_rate)
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*pi*shiftoff/samp_rate'
  states: {}
- name: collector
  id: parameter
  parameters:
    label: IP or DNS name of collector point
    type: str
    value: '"localhost"'
  states: {}
- name: collectorport
  id: parameter
  parameters:
    label: UDP port number of collector
    type: str
    value: '4729'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: GSM channel's central frequency
    short_id: f
    type: eng_float
    value: '925800000'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: RF Gain
    short_id: g
    type: eng_float
    value: '30'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc-shiftoff
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_decryption_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[]'
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    ppm: ppm-int(ppm)
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_1
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    cell_allocation: '[arfcn.downlink2arfcn(fc)]'
    osr: osr
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '1'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: 250000+abs(shiftoff)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: fc-shiftoff
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2500000'
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import gnuradio.gsm as gsm
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio.gsm import arfcn
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: collector
    mtu: '1500'
    port: '4096'
    type: UDP_CLIENT
  states: {state: disabled}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1500'
    port: '4096'
    type: UDP_SERVER
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OverSampling Ratio
    type: intx
    value: '4'
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: Clock frequency offset in ppms (1/1e6 parts)
    short_id: p
    type: eng_float
    value: '0'
  states: {}
- name: rec_len
  id: parameter
  parameters:
    label: Recording length in seconds
    short_id: T
    type: eng_float
    value: '1000000'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: str(gsm.device.get_default_args(args))
    bb_gain0: '20'
    bw0: 250e3+abs(shiftoff)
    corr0: ppm
    dc_offset_mode0: '2'
    freq0: fc-shiftoff
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: '2000000'
  states: {}
- name: serverport
  id: parameter
  parameters:
    label: UDP server listening port
    type: str
    value: '4729'
  states: {}
- name: shiftoff
  id: parameter
  parameters:
    label: Frequency Shiftoff
    short_id: o
    type: eng_float
    value: '400000'
  states: {}

connections:
- [blocks_head_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', gsm_input_0, '0']
- [gsm_bcch_ccch_sdcch4_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_1, pdus]
- [gsm_control_channels_decoder_0_0, msgs, network_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0_0, msgs, network_socket_pdu_1, pdus]
- [gsm_decryption_0, bursts, gsm_control_channels_decoder_0_0, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_bcch_ccch_sdcch4_demapper_0, bursts]
- [gsm_receiver_0, C0, gsm_sdcch8_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_decryption_0, bursts]
- [iio_pluto_source_0, '0', blocks_head_0, '0']
- [network_socket_pdu_1, pdus, gsm_message_printer_1, msgs]
- [rtlsdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
